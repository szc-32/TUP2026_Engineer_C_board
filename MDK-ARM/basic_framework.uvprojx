# Keil uVision project basic_framework.uvprojx, settings and files
target basic_framework (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: basic_framework +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CMUSE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --split_sections
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;..\Bsp\Inc;..\Algorithm;..\Modules\Inc;..\Control\Inc;..\Algorithm\Include;..\App\Inc;..\Imu_support\Inc
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --remove
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Bsp
    ../Bsp/Src/: bsp_can.cpp bsp_usart.cpp bsp_spi.cpp bsp_pwm.cpp bsp_iic.cpp bsp_gpio.cpp bsp_usb.cpp bsp_flash.cpp bsp_adc.cpp bsp_dwt.c bsp_delay.cpp
    ../Bsp/Inc/: board_def.h
  group Algorithm
    ../Algorithm/: user_lib.cpp Kalman.cpp whx_kalman_filter.cpp AHRS_middleware.cpp AHRS.lib
    ../Algorithm/Include/: arm_cortexM4lf_math.lib
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Modules
    ../Modules/Src/: motor.cpp imu.cpp super_cap.cpp remote_control.cpp referee_data.cpp ui_drawing_protocol.cpp vision.cpp buzzer.cpp led.cpp oled.cpp debug.cpp device_monitor.cpp MyAntenne_L1S.cpp tjc_usart_hmi.cpp can_commu.cpp LKMotor.cpp DMmotor.cpp
    ../Modules/Inc/: motor_def.h
    ../App/Src/: arm.cpp photogate.cpp
  group Control
    ../Control/Src/: pid.cpp ladrc.cpp ladrc_feedforward.cpp CRC8_CRC16.c crc_check.cpp
  group App
    ../App/Src/: task_center.cpp system.cpp gimbal.cpp chassis.cpp revolver.cpp message_center.cpp can_send.cpp communicate.cpp monitor.cpp draw_ui.cpp calibrate.cpp lifting.cpp suction_cup.cpp gripper.cpp moving_behavior.cpp forward_kinematics.cpp
    ../App/Inc/: robot_def.h operation_def.h forward_kinematics.h gripper.h
  group Imu_support
    ../Imu_support/Src/: BMI088driver.cpp BMI088Middleware.cpp ist8310driver.cpp ist8310driver_middleware.cpp
software components: CMSIS:CORE 5.3.0
